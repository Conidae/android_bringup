Commit message: create laser_filter

File: urdf/android_model.urdf (robot description, URDF)
Before this commit: robot android, 3 links, 2 joints
Joints:
- joint base_to_camera: origin xyz=0.225 0.0 0.3 rpy=0.0 0.0 0.0 -> xyz=0.225 0.0 0.6 rpy=0.0 0.0 0.0
